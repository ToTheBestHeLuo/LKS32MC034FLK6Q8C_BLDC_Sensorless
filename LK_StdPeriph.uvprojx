# Keil uVision project LK_StdPeriph.uvprojx, settings and files
target Linko 03x Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC033H6Q8 Linko
  pack: Linko.LKS03x.1.1.7
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LKS_MC_Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\Include;.\Kernal_Source;.\LKS32MC03x_Periph_Driver\include;.\BLDC_Sensorless\include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group AppFunction
    ./Kernal_Source/: main.c
    ./AppFunction/: hardware_init.c interrupt.c delay.c
  group Periph_Driver
    ./LKS32MC03x_Periph_Driver/Source/: lks32mc03x_adc.c lks32mc03x_cmp.c lks32mc03x_dac.c lks32mc03x_dma.c lks32mc03x_dsp.c lks32MC03x_flash.c lks32mc03x_gpio.c lks32mc03x_hall.c lks32mc03x_i2c.c lks32mc03x_iwdg.c lks32mc03x_mcpwm.c lks32mc03x_opa.c lks32mc03x_spi.c lks32mc03x_sys.c lks32mc03x_timer.c lks32mc03x_tmp.c lks32mc03x_uart.c lks32mc03x_nvr.lib startup_lks32mc03x.s
  group BLDC
    ./BLDC_Sensorless/source/: bldcDriver.c
software components: CMSIS:CORE 5.5.0
